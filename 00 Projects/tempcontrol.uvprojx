# Keil uVision project tempcontrol.uvprojx, settings and files
target ucosii (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tempcontrol +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,
  c include: ..\01 FWlib\inc;..\02 uCOSii\Ports;..\02 uCOSii\Source;..\03 Driver\00 Config;..\03 Driver\01 Core;..\03 Driver\02 Bsp\BSP_Adc;..\03 Driver\02 Bsp\BSP_Can;..\03 Driver\02 Bsp\BSP_Gpio;..\03 Driver\02 Bsp\BSP_Spi;..\03 Driver\02 Bsp\BSP_Timer;..\03 Driver\02 Bsp\BSP_Sys;..\03 Driver\02 Bsp\BSP_Uart;..\03 Driver\03 Device\Drv_AT24C32;..\03 Driver\03 Device\Drv_Fan;..\03 Driver\03 Device\Drv_Heat;..\03 Driver\03 Device\Drv_Led;..\03 Driver\03 Device\Drv_MotionControlComponents;..\03 Driver\03 Device\Drv_Pid;..\03 Driver\03 Device\Drv_Pump;..\03 Driver\03 Device\Drv_PWM_TimerDriven;..\03 Driver\03 Device\Drv_Relay;..\03 Driver\03 Device\Drv_SimulateIic;..\03 Driver\03 Device\Drv_StepMotor;..\03 Driver\03 Device\Drv_SwitchingSensor;..\03 Driver\03 Device\Drv_Valve;..\05 Protocol\Prt_CmdDoubleList;..\05 Protocol\Prt_CmdRegedit;..\05 Protocol\Prt_CmdScheduler;..\06 Management;..\04 Function\00 Func_Common;..\04 Function\02 Func_LiquidControl;..\04 Function\01 Func_TempControl;..\03 Driver\03 Device\Drv_UartDataInterface;..\03 Driver\03 Device\Drv_Refrigerating;..\03 Driver\03 Device\Drv_NtcTemp;..\03 Driver\03 Device\Drv_X100m
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group UCOSII/PORT
    ../04 Function/00 Func_Common/: Common_Cmd.h
    ../02 uCOSii/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group STD_FWLIB
    ../01 FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group UCOSII/SOURCE
    ../02 uCOSii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group DRIVER/CORE
    ../03 Driver/01 Core/: startup_stm32f10x_hd.s stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h core_cm3.c
  group DRIVER/CONFIG
    ../03 Driver/00 Config/: includes.h os_cfg.h stm32f10x.h stm32f10x_conf.h
  group DRIVER/BSP
    ../03 Driver/02 Bsp/BSP_Adc/: BSP_Adc.c
    ../03 Driver/02 Bsp/BSP_Can/: BSP_Can.c
    ../03 Driver/02 Bsp/BSP_Gpio/: BSP_Gpio.c
    ../03 Driver/02 Bsp/BSP_Spi/: BSP_Spi.c
    ../03 Driver/02 Bsp/BSP_Sys/: BSP_Sys.c
    ../03 Driver/02 Bsp/BSP_Timer/: BSP_Timer.c
    ../03 Driver/02 Bsp/BSP_Uart/: BSP_Uart.c
  group DRIVER/DEVICE
    ../03 Driver/03 Device/Drv_AT24C32/: Drv_AT24C32.c
    ../03 Driver/03 Device/Drv_Pid/: Drv_Pid.c
    ../03 Driver/03 Device/Drv_Fan/: Drv_Fan.c
    ../03 Driver/03 Device/Drv_Heat/: Drv_Heat.c
    ../03 Driver/03 Device/Drv_Led/: Drv_Led.c
    ../03 Driver/03 Device/Drv_MotionControlComponents/: Drv_MotionControlComponents.c
    ../03 Driver/03 Device/Drv_Pump/: Drv_Pump.c
    ../03 Driver/03 Device/Drv_PWM_TimerDriven/: Drv_PWM_TimerDriven.c
    ../03 Driver/03 Device/Drv_Relay/: Drv_Relay.c
    ../03 Driver/03 Device/Drv_SimulateIic/: Drv_SimulateIic.c
    ../03 Driver/03 Device/Drv_StepMotor/: Drv_StepMotor.c
    ../03 Driver/03 Device/Drv_SwitchingSensor/: Drv_SwitchingSensor.c
    ../03 Driver/03 Device/Drv_Valve/: Drv_Valve.c
    ../03 Driver/03 Device/Drv_UartDataInterface/: Drv_UartDataInterface.c
    ../03 Driver/03 Device/Drv_NtcTemp/: Drv_NtcTemp.c
    ../03 Driver/03 Device/Drv_Refrigerating/: Drv_Refrigerating.c
    ../03 Driver/03 Device/Drv_X100m/: Drv_X100m.c
  group FUNCTION/COMMON
    ../04 Function/00 Func_Common/: Common_Cmd.c
  group FUNCTION/PRIVATE
    ../04 Function/01 Func_TempControl/: Func_TempControl.c
  group MANAGEMENT
    ../06 Management/: Main.c Task.c Task.h
  group PROTOCOL/REGISTER
    ../05 Protocol/Prt_CmdRegedit/: Prt_CmdRegedit.c
  group PROTOCOL/SCHEDULE
    ../05 Protocol/Prt_CmdScheduler/: Prt_CmdScheduler.c
  group PROTOCOL/DOUBLELIST
    ../05 Protocol/Prt_CmdDoubleList/: Prt_CmdDoubleList.c
